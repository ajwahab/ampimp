# Keil uVision project HelloWorld.uvprojx, settings and files
target HelloWorld Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HelloWorld
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
  group Source
    ../../: HelloWorld.c
  group Readme
    ./: Readme_HelloWorld.txt
target HelloWorld Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM3029 Analog Devices
  pack: AnalogDevices.ADuCM302x_DFP.2.1.0
  cpu: as above
  output: HelloWorld
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x4000
software components: CMSIS:CORE 5.0.1, Device:Drivers:DMA 2.0.0, Device:Drivers:Power 2.0.0, Device:Drivers:UART 2.0.0, Device:Global Configuration 2.0.0, Device:Retarget_UART 2.0.0, Device:Startup 2.0.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
